# Keil uVision project STm32-FD-Touch.uvprojx, settings and files
target STM32-FD-TOUCH (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-fd-touch +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\FWlib\inc;.\user;.\CM3;.\MALLOC;.\TFT;.\EMWIN\EMWIN_INC;.\EMWIN\DEMO;.\PNG;.\FATFS;.\SDIO;.\USB\inc;.\USBCFG\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group User
    ./user/: stm32f10x_it.c main.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_sdio.c
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
  group TFT
    ./TFT/: fsmc_sram.c lcd_dis24.c
  group EMWIN_Config
    ./EMWIN/EMWIN_Config/: GUI_VNC_X.c GUI_X.c GUIConf.c LCDConf.c GUIDRV_Template.c
  group EMWIN_LIB
    ./EMWIN/EMWIN_LIB/: STemWin522_CM3_Keil.lib
  group PNG
    ./PNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group DEMO
    ./EMWIN/DEMO/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group SDIO
    ./SDIO/: sdio_sdcard.c
  group FATFS
    ./FATFS/: diskio.c ff.c
    ./FATFS/option/: cc936.c
  group USB
    ./USB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USBCFG
    ./USBCFG/scr/: hw_config.c mass_mal.c memory.c nand_if.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
