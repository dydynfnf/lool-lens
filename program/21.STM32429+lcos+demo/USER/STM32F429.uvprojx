# Keil uVision project STM32F429.uvprojx, settings and files
target Strive (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: D:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;..\USER;..\FWLIB\inc;..\SYS;..\MEM;..\LCD\Fonts;..\LCD\Stm32F429_LCD;..\LCD\LCD_480_272;..\LCD\LCOS_300_224;..\EMWIN\EMWIN_INC;..\PNG;..\USB\USB_APP\inc;..\USB\USB_Device\inc;..\USB\USB_Driver\inc;..\FATFS;..\FUNCTION;..\DEMO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f4xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_dma2d.c stm32f4xx_spi.c
  group SYS
    ../SYS/: delay.c
  group MEM
    ../MEM/: NandFlash.c SDRAM.c W25Qxx.c
  group LCD
    ../LCD/Stm32F429_LCD/: Stm32F429_LCD.c
    ../LCD/LCOS_300_224/: lcos_300_224.c
  group EMWIN_Config
    ../EMWIN/EMWIN_Config/: GUI_VNC_X.c GUI_X.c GUIConf.c LCDConf.c GUIDRV_Layer1.c GUIDRV_Layer0.c
  group EMWIN_LIB
    ../EMWIN/EMWIN_LIB/: GUI_CM4F_L.lib
  group PNG
    ../PNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group USB APP
    ../USB/USB_APP/src/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group USB Driver
    ../USB/USB_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB Device
    ../USB/USB_Device/src/: usbd_core.c usbd_ioreq.c usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c usbd_req.c
  group FATFS
    ../FATFS/: diskio.c ff.c
    ../FATFS/option/: cc936.c
  group FUNCTION
    ../FUNCTION/: font.c picture.c
  group DEMO
    ../DEMO/: time.c weather.c nav.c motion.c
